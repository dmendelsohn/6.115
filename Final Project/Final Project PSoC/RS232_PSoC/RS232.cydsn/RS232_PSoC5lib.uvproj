# Keil uVision project RS232_PSoC5lib.uvproj, settings and files
target Debug (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: "IRAM(0x1FFF8000-0x20007FFF)IROM(0x0-0x3FFFF)CLOCK(67000000)CPUTYPE( "Cortex-M3") ESEL ELITTLE"
  output: RS232_PSoC5lib (library)
  group Source Files
    ./Generated_Source/PSoC5/: cyfitter_cfg.h cyfitter_cfg.c cydevice.h cydevicegnu.inc cydevicerv.inc cydevice_trm.h cydevicegnu_trm.inc cydevicerv_trm.inc cyfittergnu.inc cyfitterrv.inc cyfitter.h cm3gcc.ld Cm3RealView.scat core_cm3_psoc5.h core_cm3.c core_cm3.h CyBootAsmGnu.s CyDmac.c CyDmac.h CyFlash.c CyFlash.h CyLib.c CyLib.h cypins.h cyPm.c cyPm.h CySpc.c CySpc.h cytypes.h cyutils.c project.h LCD.c LCD.h LCD_PM.c LCD_LCDPort_aliases.h LCD_LCDPort.c LCD_LCDPort.h UART.c UART.h UART_PM.c UART_INT.c tx_int.c tx_int.h rx_int.c rx_int.h TX_aliases.h TX.c TX.h RIGHT_PIN_aliases.h RIGHT_PIN.c RIGHT_PIN.h LEFT_PIN_aliases.h LEFT_PIN.c LEFT_PIN.h TEST_PIN_aliases.h TEST_PIN.c TEST_PIN.h MID_PIN_aliases.h MID_PIN.c MID_PIN.h DOWN_PIN_aliases.h DOWN_PIN.c DOWN_PIN.h UP_PIN_aliases.h UP_PIN.c UP_PIN.h ADC.c ADC.h ADC_PM.c ADC_INT.c ADC_theACLK.c ADC_theACLK.h ADC_Ext_CP_Clk.c ADC_Ext_CP_Clk.h ADC_AMux.c ADC_AMux.h AMux.c AMux.h Clock_1.c Clock_1.h ISR.c ISR.h
target Release (ARM-GNU)
  device: CY8C5868AXI-LP035 Cypress
  cpu: as above
  output: RS232_PSoC5lib (library)
